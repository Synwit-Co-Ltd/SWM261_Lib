# IAR project SPIFlash_NAND.ewp, settings and files
configuration SWM261 (ARM, debug)
  General.OGChipSelectEditMenu: SWM261xB Synwit SWM261xB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: _DLIB_FILE_DESCRIPTOR; CHIP_SWM261
  ICCARM.CCIncludePath2: ..\..\SWM261_StdPeriph_Driver\CSL\CMSIS\CoreSupport; ..\..\SWM261_StdPeriph_Driver\CSL\CMSIS\DeviceSupport; ..\..\SWM261_StdPeriph_Driver\CSL\SWM261_StdPeriph_Driver; .\APP
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: _DLIB_FILE_DESCRIPTOR; CHIP_SWM261
  OBJCOPY.OOCOutputFile: SPIFlash_NAND.bin
  ILINK.IlinkOutputFile: SPIFlash_NAND.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group APP
    APP/: main.c W25N01G.c
  group CSL\CMSIS
    ../../SWM261_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/startup/iar/: startup_SWM261.s
    ../../SWM261_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/: system_SWM261.c
  group CSL\StdPD
    ../../SWM261_StdPeriph_Driver/CSL/SWM261_StdPeriph_Driver/: SWM261_adc.c SWM261_can.c SWM261_div.c SWM261_dma.c SWM261_exti.c SWM261_flash.c SWM261_gpio.c SWM261_i2c.c SWM261_mpu.c SWM261_port.c SWM261_pwm.c SWM261_qei.c SWM261_spi.c SWM261_timr.c SWM261_uart.c SWM261_wdt.c
