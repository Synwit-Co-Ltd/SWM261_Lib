# Keil uVision project SimplMPU.uvprojx, settings and files
target SWM261 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: SWM261xC Synwit
  pack: Synwit.SWM32_DFP.1.21.0
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: SimplMPU +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  AfterMake: fromelf --text -a -c -o "$L@L.asm" "#L"
  c flags: Optim=2 v6Lang=1 v6LangP=1
  c define: CHIP_SWM261
  c include: ..\..\SWM261_StdPeriph_Driver\CSL\CMSIS\CoreSupport;..\..\SWM261_StdPeriph_Driver\CSL\CMSIS\DeviceSupport;..\..\SWM261_StdPeriph_Driver\CSL\SWM261_StdPeriph_Driver
  asm define: CHIP_SWM261
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group APP
    ./app/: main.c
    ./APP/: NT35510.c ugui.c
  group CSL\StdPD
    ../../SWM261_StdPeriph_Driver/CSL/SWM261_StdPeriph_Driver/: SWM261_adc.c SWM261_exti.c SWM261_gpio.c SWM261_i2c.c SWM261_pwm.c SWM261_timr.c SWM261_uart.c SWM261_wdt.c SWM261_port.c SWM261_rtc.c SWM261_flash.c SWM261_cordic.c SWM261_div.c SWM261_dma.c SWM261_qei.c SWM261_sleep.c SWM261_spi.c SWM261_mpu.c
  group CSL\CMSIS
    ../../SWM261_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/: system_SWM261.c
    ../../SWM261_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/startup/arm/: startup_SWM261.s
