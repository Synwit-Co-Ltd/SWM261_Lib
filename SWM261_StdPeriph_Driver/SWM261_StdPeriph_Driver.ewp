# IAR project SWM261_StdPeriph_Driver.ewp, settings and files
configuration SWM261 (ARM, debug)
  General.OGChipSelectEditMenu: SWM261xB Synwit SWM261xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: _DLIB_FILE_DESCRIPTOR; CHIP_SWM261
  ICCARM.CCIncludePath2: .\CSL\CMSIS\CoreSupport; .\CSL\CMSIS\DeviceSupport; .\CSL\SWM261_StdPeriph_Driver
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: _DLIB_FILE_DESCRIPTOR; CHIP_SWM261
  OBJCOPY.OOCOutputFile: SWM261_StdPeriph_Driver.srec
  ILINK.IlinkOutputFile: SWM261_StdPeriph_Driver.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group APP
    ./app/: main.c
  group CSL\StdPD
    ./CSL/SWM261_StdPeriph_Driver/: SWM261_port.c SWM261_gpio.c SWM261_exti.c SWM261_timr.c SWM261_uart.c SWM261_adc.c SWM261_i2c.c SWM261_pwm.c SWM261_wdt.c SWM261_sleep.c SWM261_div.c SWM261_spi.c SWM261_qei.c SWM261_dma.c SWM261_can.c SWM261_flash.c SWM261_iofilt.c SWM261_mpu.c SWM261_qspi.c SWM261_crc.c SWM261_usart.c
  group CSL\CMSIS
    ./CSL/CMSIS/DeviceSupport/: system_SWM261.c
    ./CSL/CMSIS/DeviceSupport/startup/iar/: startup_SWM261.s
