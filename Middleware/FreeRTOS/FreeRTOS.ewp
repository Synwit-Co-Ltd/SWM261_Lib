# IAR project FreeRTOS.ewp, settings and files
configuration SWM261 (ARM, debug)
  General.OGChipSelectEditMenu: SWM261xB Synwit SWM261xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: _DLIB_FILE_DESCRIPTOR; CHIP_SWM261
  ICCARM.CCIncludePath2: ..\..\SWM261_StdPeriph_Driver\CSL\CMSIS\CoreSupport; ..\..\SWM261_StdPeriph_Driver\CSL\CMSIS\DeviceSupport; ..\..\SWM261_StdPeriph_Driver\CSL\SWM261_StdPeriph_Driver; .\APP; .\APP\FreeRTOS\include; .\APP\FreeRTOS\portable\IAR\ARM_CM0
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: _DLIB_FILE_DESCRIPTOR; CHIP_SWM261
  AARM.AUserIncludes: .\APP
  OBJCOPY.OOCOutputFile: FreeRTOS.srec
  ILINK.IlinkOutputFile: FreeRTOS.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group APP
    ./app/: main.c
  group FreeRTOS
    ./APP/FreeRTOS/: list.c queue.c tasks.c timers.c croutine.c
  group FreeRTOS\port
    ./APP/FreeRTOS/portable/IAR/ARM_CM0/: portasm.s port.c
    ./APP/FreeRTOS/portable/MemMang/: heap_4.c
  group CSL\StdPD
    ../../SWM261_StdPeriph_Driver/CSL/SWM261_StdPeriph_Driver/: SWM261_adc.c SWM261_exti.c SWM261_gpio.c SWM261_i2c.c SWM261_pwm.c SWM261_timr.c SWM261_uart.c SWM261_wdt.c SWM261_port.c SWM261_flash.c
  group CSL\CMSIS
    ../../SWM261_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/: system_SWM261.c
    ../../SWM261_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/startup/iar/: startup_SWM261.s
